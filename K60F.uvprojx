# Keil uVision project K60F.uvprojx, settings and files
target 64f (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MK64FX512xxx12 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x80000) IROM2(0x10000000,0x20000) IRAM(0x20000000,0x20000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: K60F +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: MK64F12  CC_ARM
  c include: .\drives;.\drives\include;.\drives\app;.\drives\startup;.\drives\drives;.\drives\drives\gpio;.\drives\drives\PIT;.\drives\drives\adc;.\drives\drives\delay;.\drives\drives\Flash;.\drives\drives\FTM;.\drives\drives\i2c;.\drives\drives\lptmr;.\drives\drives\spi;.\drives\drives\uart;.\drives\drives\dma;.\drives\drives\CAN;.\drives\landzo_drives;.\drives\app\control;.\drives\app\Att_Q;.\drives\app\control_Landzo
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group startup
    ./drives/startup/: startup_MK64F12.s system_MK64F12.c
  group app
    ./drives/app/: main.c isr.c DATA_SEND_PC.C RC.C
  group drieves
    ./drives/drives/gpio/: K6x_gpio.c
    ./drives/drives/adc/: K6x_adc.c
    ./drives/drives/delay/: K6x_delay.c
    ./drives/drives/dma/: K6x_dma.c
    ./drives/drives/Flash/: K6x_flash.c
    ./drives/drives/i2c/: K6x_i2c.c
    ./drives/drives/spi/: K6x_spi.c
    ./drives/drives/lptmr/: K6x_lptmr.c
    ./drives/drives/uart/: K6x_uart.c
    ./drives/drives/CAN/: K6x_can.c
    ./drives/drives/PIT/: K6x_PIT.c
    ./drives/drives/FTM/: K6x_FTM.c
  group include
    ./drives/include/: include.h common.h
    ./drives/drives/gpio/: gpio_cfg.h port.h pin_cfg.h
    ./drives/startup/: system_MK64F125.h
  group landzo_drive
    ./drives/landzo_drives/: KEY.c landzo_app.c landzo_fxos8700.C landzo_MPL3115A2.C landzo_FXAS21002.C
  group control
    ./drives/app/control_Landzo/: control_L.c control_L.h
  group Att_Q
    ./drives/app/Att_Q/: Att_Q.c Att_Q.h
